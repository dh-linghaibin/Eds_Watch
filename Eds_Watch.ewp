# IAR project Eds_Watch.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: Eds_Watch.out
  group (top)
    ./: Botton.c Com.c Ds1302.c Eelay.c Eeprom.c Htlcd.c Led.c main.c Menu.c Speed.c Sys.c Timer.c
